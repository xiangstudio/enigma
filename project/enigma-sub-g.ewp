# IAR project enigma-sub-g.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\bsp\cmt2300; ..\bsp\cmt2300; .\bsp\cmt2300; ..\..\bsp; ..\bsp; ..\..\..\..\enigma_sub_g_stm8l051f3_iar-common; ..\..\..\enigma_sub_g_stm8l051f3_iar-common; ..\..\enigma_sub_g_stm8l051f3_iar-common; .\bsp; ..\..\driver\inc; ..\driver\inc; .\driver\inc; ..\..\main; ..\main; .\main
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: enigma-sub-g-slave.hex
  ILINK.IlinkOutputFile: enigma-sub-g.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: my_command.c my_command.h my_i2c.c my_i2c.h my_rf.c my_rf.h
  group bsp/cmt2300
    ../bsp/cmt2300/: 868.35_2.4k_35k_Var.h CMT2300_GPIO_Define.h CMT2300A_AdvDriver.h CMT2300A_EasyDriver.c CMT2300A_EasyDriver.h CMT2300A_EasyDriver_Function.h CMT2300A_Register.h CMT2300A_SLPDriver.h HopeDuino_SPI3.c HopeDuino_SPI3.h HopeDuino_SPI3_Function.h RadioCfg868350K2K5KHz13dBm.h RadioCfg868350K2K5KHz20dBm.h RFCFG_433.92_2.4K_35K_0dBm.h RFCFG_433.92_2.4K_35K_13dBm.h RFCFG_433.92_2.4K_35K_13dBm_20.h RfCongfig433.92_2.4k_35k.h RfCongfig868.35_2.4k_35k.h
  group driver/inc
    ../driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group driver/src
    ../driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_rtc.c stm8l15x_syscfg.c
  group main
    ../main/: main.c main.h my_tools.c my_tools.h my_types.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    ../../enigma_sub_g_stm8l051f3_iar-common/: my_common.h
